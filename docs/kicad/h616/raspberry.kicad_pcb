# Repository MagicPrince666/smart_car_chassis

File README.md:

# linux 小车

## 电路图

### [MangoPi MQ QUAD 智能小车.](docs/Mangopi_MQ_Quad_Two_wheel.md)
### [LubancatzeroW 智能小车.](docs/LubanCat_Zero_W.md)

* 码农不易 尊重劳动
* 作者：大魔王与木头人
* 功能：基于Linux 的智能小车
* QQ：846863428
* TEL: 15220187476
* email: 846863428@qq.com
* 修改时间 ：2023-01-10

If you find my work useful and you want to encourage the development of more free resources, you can do it by donating…

觉得不错给鼓励一下

**拿人家代码不star不fork的都是耍流氓**

## network_manager 连接
```bash
sudo nmcli dev wifi connect OpenWrt_R619ac_2.4G password 67123236
```

## 安装依赖
```bash
sudo apt install -y g++ cmake git libyaml-cpp-dev
sudo apt install -y libgl1-mesa-dev libglu1-mesa-dev mesa-utils xorg swig
sudo apt install -y libgl1-mesa-glx libgl1-mesa-dri libglx-mesa0 libqt5opengl5-dev
sudo apt install ros-$ROS_DISTRO-rviz2
```

## 设置进本机通讯
对不需要联机场景，设置仅本行通讯
```bash
export ROS_LOCALHOST_ONLY=1
```
在 ~/.bashrc里面加入，每次打开终端都生效

## 安装TF tree发布工具
```bash
sudo apt install -y ros-$ROS_DISTRO-tf2-sensor-msgs
sudo apt install -y ros-$ROS_DISTRO-joint-state-publisher-gui ros-$ROS_DISTRO-robot-state-publisher
```

## 安装IMU显示插件
```bash
sudo apt install ros-$ROS_DISTRO-imu-tools
```

## 安装rqt
```bash
sudo apt install ros-$ROS_DISTRO-rqt
sudo apt install ros-$ROS_DISTRO-rqt-common-plugins
```

## 安装slam应用
```bash
sudo apt install ros-$ROS_DISTRO-cartographer ros-$ROS_DISTRO-cartographer-ros ros-$ROS_DISTRO-nav2-map-server
sudo apt install ros-$ROS_DISTRO-pcl*
```

## 编译ROS2
```bash
colcon build --packages-select chassis
colcon build --packages-select ydlidar
colcon build --packages-select ldlidar_stl_ros2
colcon build --packages-select fishbot_cartographer
colcon build --packages-select fishbot_description
```

## 编译ROS1
```bash
catkin_make -DCATKIN_WHITELIST_PACKAGES="chassis;ydlidar"
```

## 调试udev
```bash
udevadm info --query=all --name=sda # 查询sda的所有信息
udevadm info --query=path --name=sda # 查看sda的path
udevadm info --attribute-walk --name=/dev/nvme0n1  # 查看nvme0n1的所有父设备一直到sysfs的根节点
udevadm monitor --property   # 输出事件的属性
udevadm monitor --kernel --property --subsystem-match=usb    # 过滤监听符合条件的时间
udevadm info -q path -n /dev/sda # 查询/dev/sda设备的系统设备路径
udevadm info -q symlink -n /dev/sda # 查询/dev/sda设备的符号链接文件
udevadm info -q all -n /dev/sda # 查询/dev/sda设备的所有的值
udevadm info -a -p /sys/block/sda   # 查询系统设备的路径/sys/block/sda
```

```bash
KERNEL=="eth*", ATTR{address}=="00:52:8b:d5:04:48", NAME="lan"
```

## 启动底盘
```bash
sudo cp src/chassis/scripts/99-hardware-conf.rules /etc/udev/rules.d/
sudo udevadm control --reload-rules && sudo udevadm trigger
sudo src/chassis/scripts/luban_cat_ackerman_setup.sh # 解决权限问题
source install/setup.bash
ros2 launch chassis ackerman_chassis.launch.py # 单启动底盘
```

## slam建图
### 前提1：确保小车底盘节点已启动
底盘节点有多个启动脚本，确认脚本对应的底盘一致，比如阿克曼底盘，乐动雷达对应的脚本是ackerman_ld06_lidar.launch.py

### 前提2：确保雷达点云正常发布 ros2 topic list 可以看到/scan话题
不一定是/scan,话题名称可变，活学活用

### 前提3：确保雷达点云正常接收
rviz2可以接收点云数据并显示

### 前提4：确保建图节点已安装
若未安装，请先安装，安装命令
```bash
sudo apt install ros-$ROS_DISTRO-cartographer ros-$ROS_DISTRO-cartographer-ros ros-$ROS_DISTRO-nav2-map-server
```
雷达建图脚本放在了chassis的launch目录下，可以酌情移动到别的包里面

### 启动方案1
小车启动底盘雷达tf节点，电脑端或小车执行建图
```bash
# 第一步，启动小车底盘，必须在小车端操作
source install/setup.bash # 编译源码一定要source工作空间下的install/setup.bash
sudo src/chassis/scripts/luban_cat_ackerman_setup.sh # 解决权限问题，执行一次即可，重启后必须先执行一遍
ros2 launch chassis ackerman_ld06_lidar.launch.py # 一键启动底盘雷达tf节点
# 第二步 启动建图节点，可以在小车端执行，已经在互通的电脑端运行
ros2 launch fishbot_cartographer cartographer.launch.py    # 开始建图，这是自定义的包，包在工作空间的src/fishbot_cartographer下
ros2 run nav2_map_server map_saver_cli -t map -f my_map # 地图保存
```

### 启动方案2
小车一键建图
```bash
# 启动小车一键建图，必须在小车端操作
source install/setup.bash # 编译源码一定要source工作空间下的install/setup.bash
sudo src/chassis/scripts/luban_cat_ackerman_setup.sh # 解决权限问题，执行一次即可，重启后必须先执行一遍
ros2 launch chassis slam_ldlidar_ld06.launch.py    # 开始建图，这是自定义的包，包在工作空间的src/fishbot_cartographer下
ros2 run nav2_map_server map_saver_cli -t map -f my_map # 地图保存
```

## 键盘控制
```bash
sudo apt install ros-$ROS_DISTRO-teleop-twist-keyboard
ros2 run teleop_twist_keyboard teleop_twist_keyboard
```

## 查看CPU频率
```bash
cat /sys/devices/system/cpu/cpu0/cpufreq/scaling_cur_freq
```
## 查看cpu温度
```bash
sudo apt install lm-sensors -y

sensors # 运行
```
or
```bash
cat /sys/devices/virtual/thermal/thermal_zone0/temp
```
开启风扇
```bash
echo 8 > /sys/class/thermal/cooling_device0/cur_state
```
Jetson nano开启风扇
```bash
sudo bash -c  'echo 120 > /sys/devices/pwm-fan/target_pwm' # 范围0-255
```

## 设置交换空间
完成下面的步骤，在 Ubuntu 20.04 上添加交换空间：

1. 首先，创建一个用作交换文件的文件：
```bash
sudo fallocate -l 2G /swapfile
```
如果fallocate工具在你的系统上不可用，或者你获得一个消息：fallocate failed: Operation not supported，使用下面的命令去创建交换文件：

```bash
sudo dd if=/dev/zero of=/swapfile bs=1024 count=2097152
```

2. 设置文件权限到600阻止常规用户读写这个文件：
```bash
sudo chmod 600 /swapfile
```

3. 在这个文件上创建一个 Linux 交换区：
```bash
sudo mkswap /swapfile
```
输出如下：
```
Setting up swapspace version 1, size = 2 GiB (2147479552 bytes)
no label, UUID=fde7d2c8-06ea-400a-9027-fd731d8ab4c8
```

4. 通过运行下面的命令，激活交换区：
```bash
sudo swapon /swapfile
```
想要持久化，打开/etc/fstab文件：
```bash
sudo nano /etc/fstab
```
并且粘贴下面的行：
```bash
/swapfile swap swap defaults 0 0
```
5. 使用swapon或者free命令来验证交换区是否已激活，像下面这样：
```bash
sudo swapon --show
NAME      TYPE      SIZE  USED PRIO
/swapfile file        2G    0B   -1
sudo free -h
total        used        free      shared  buff/cache   available
Mem:          981Mi        97Mi        68Mi       0.0Ki       814Mi       735Mi
Swap:         2.0Gi        10Mi       1.9Gi
```
6. 关闭交换空间
```bash
sudo swapoff /swapfile
```

## 添加开机自启动脚本(示例)
1. 建立frpc.service文件
```
sudo vim /lib/systemd/system/frpc.service
```

输入如下内容
```bash
[Unit]
Description=frpc
Requires=network.target
After=network.target

[Service]
Type=forking
ExecStart=/home/firefly/frp_0.48.0_linux_arm64/start_frpc.sh
Restart=always
RestartSec=60

[Install]
WantedBy=multi-user.target
```

2. 创建start_frpc.sh
```bash
sudo vim /home/firefly/frp_0.48.0_linux_arm64/start_frpc.sh
```
输入内容
```bash
#!/bin/bash

DIR="/home/leo/frp_0.51.3_linux_amd64"

processNum=`ps -ef | grep $DIR/frpc | grep -v grep | wc -l`
echo $processNum

if [ $processNum -eq 0 ]; then
	echo "frpc start"
	$DIR/frpc -c $DIR/frpc.ini &
else
	echo "frpc running"
fi
```

3. 添加可执行权限
```bash
sudo chmod +x /home/firefly/frp_0.48.0_linux_arm64/start_frpc.sh
```

4. 创建软链接
```bash
sudo ln -s /lib/systemd/system/frpc.service /etc/systemd/system/frpc.service
```

5. 使能自启动
```bash
sudo systemctl start frpc.service # 启动
sudo systemctl status frpc.service # 查看状态
sudo systemctl enable frpc.service # 开机自启动
```

## 小车自启动脚本
```bash
cp src/chassis/scripts/cat_ld06_start/luban_cat_ackerman_setup.sh /home/cat
cp src/chassis/scripts/cat_ld06_start/chassis.service /lib/systemd/system
sudo ln -s /lib/systemd/system/chassis.service /etc/systemd/system/chassis.service
sudo systemctl start chassis.service # 启动底盘
sudo systemctl stop chassis.service # 停止底盘
sudo systemctl status chassis.service # 查看状态
sudo systemctl enable chassis.service # 开机自启动
sudo systemctl disenable chassis.service # 关闭开机自启动
```

## KiCad design docs/kicad/h616/raspberry.kicad_pcb

Parts:
C1, C18: 10uf; C_0805_2012Metric
C2: C_Polarized_Small_US; CP_Radial_D5.0mm_P2.50mm
C3, C7, C10, C13, C14, C16: 10uF; C_0603_1608Metric
C4: 100pF; C_0402_1005Metric
C5, C6, C8: 100nF; C_0402_1005Metric
C9, C11, C12, C15, C21, C22, C23: 104; C_0402_1005Metric
C17: 2200pf; C_0402_1005Metric
C19, C20: 22PF; C_0402_1005Metric
C24, C25: 50V/47P; C_0402_1005Metric
C26: 4700pF; C_0402_1005Metric
D1, D2: D_Dual_CommonCathode_AAK; SOT-23-3
D9: D; D_MELF
J1: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J7: EAI_S4
J8: Barrel_Jack_Switch_Pin3Ring; BarrelJack_GCT_DCJ200-10-A_Horizontal
L1: 4.7uH; L_6.3x6.3_H3
M1, M2: MOTO_CHIMING; PinSocket_1x06_P2.00mm_Vertical
Q1: S8050; SOT-23
Q2, Q3, Q4, Q5: BTN8982TA; TO-263-7_TabPin8
R1, R2, R7: 10K; R_0402_1005Metric
R3, R4, R5: 4.7K; R_0402_1005Metric
R6, R28: 62; R_0402_1005Metric
R8, R11, R12, R13: 100K; R_0402_1005Metric
R9: 40.2K; R_0402_1005Metric
R10: 210K; R_0402_1005Metric
R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27: 1K; R_0402_1005Metric
U1: 树莓派接口; HEARD2x40
U2: 贴片2.4寸TFT带触摸屏; 2.4TFT_TOUCH
U3: MPU-6050; InvenSense_QFN-24_4x4mm_P0.5mm
U4: XPT2046TS; TSSOP-16_4.4x5mm_P0.65mm
U5: 74AHC244
U6: MP1584EN; HTSOP-8-1EP_3.9x4.9mm_Pitch1.27mm_LargeCopper
U7: MCP2517FD-xJHA; DFN-14-1EP_3x4.5mm_P0.65mm_EP1.65x4.25mm
U8: ATA6560-GAQW; HTSOP-8-1EP_3.9x4.9mm_Pitch1.27mm_ThermalVias
Y1: 40M; Oscillator_SMD_Abracon_ASCO-4Pin_1.6x1.2mm

Connections:
+3.3V: C1.1, C9.2, C10.2, C11.1, C13.2, C14.1, C15.1, C16.1, C18.2, C21.2, C23.2, M1.2 (5V), M2.2 (5V), R2.1, R3.1, R4.1, R7.2, U1.1 (3.3V), U1.17 (3.3V), U2.9 (VCC), U2.10 (LEDA), U3.8 (VDDIO), U3.13 (VDD), U4.1 (VCC), U4.9 (VREF), U4.10 (IOVDD), U5.20 (VCC), U7.14 (VDD), U8.5 (NSIL)
+5V: C3.1, C5.1, C22.2, J7.4 (5V), L1.1, R10.1, U1.2 (5V), U1.4 (5V), U8.3 (VCC)
+12V: C2.1, C7.1, C8.2, J8.1, Q2.7, Q3.7, Q4.7, Q5.7, R12.1, U6.7 (VIN)
/CAN_INT: U1.40 (GPIO.29), U7.4 (~INT)
/CS0: U1.24 (CE0), U4.15 (~CS)
/CS1: U1.26 (CE1), U2.5 (CS)
/CS3: U1.37 (GPIO.25), U7.13 (nCS)
/DC: U1.29 (GPIO.21), U2.4 (DCX)
/M1+: M1.1 (OUT1), Q2.4, Q2.8
/M1-: M1.6 (OUT2), Q3.4, Q3.8
/M1_E1: M1.4 (E1), U1.3 (SDA.1)
/M1_E2: M1.3 (E2), U1.5 (SCL.1)
/M1_EN1: R14.2, U1.18 (GPIO.5), U5.2 (1A0)
/M1_EN2: R16.2, U1.13 (GPIO.2), U5.6 (1A2)
/M2+: M2.1 (OUT1), Q4.4, Q4.8
/M2-: M2.6 (OUT2), Q5.4, Q5.8
/M2_E1: M2.4 (E1), U1.35 (GPIO.24)
/M2_E2: M2.3 (E2), U1.36 (GPIO.27)
/M2_EN1: R17.2, U1.11 (GPIO.0), U5.17 (2A0)
/M2_EN2: R19.2, U1.7 (GPIO.7), U5.13 (2A2)
/MISO: U1.21 (MISO), U2.7 (MISO), U4.12 (DOUT), U7.12 (SDO)
/MOSI: U1.19 (MOSI), U2.6 (MOSI), U4.14 (DIN), U7.11 (SDI)
/MPU_INT: U1.38 (GPIO.28), U3.12 (INT)
/PWM0: J7.1 (PWM), U1.12 (GPIO.1)
/PWM2: R1.1, U1.31 (GPIO.22)
/PWM3: R18.2, U1.15 (GPIO.3), U5.11 (2A3), U5.15 (2A1)
/PWM4: R15.2, U1.16 (GPIO.4), U5.4 (1A1), U5.8 (1A3)
/RESET: R2.2, U2.2 (RESET)
/RXD0: U1.10 (RXD)
/RXD2: J7.3 (TX), U1.22 (GPIO.6)
/SCL0: R4.2, U1.28 (SCL.0), U3.23 (SCL)
/SCLK: U1.23 (SCLK), U2.3 (SCL), U4.16 (DCLK), U7.10 (SCK)
/SDA0: R3.2, U1.27 (SDA.0), U3.24 (SDA)
/TXD0: U1.8 (TXD)
/TXD2: U1.32 (GPIO.26)
/T_IRQ: R7.1, U1.33 (GPIO.23), U4.11 (~PENIRQ)
/XN: U2.15 (X-), U4.4 (XN)
/XP: U2.17 (X+), U4.2 (XP)
/YN: U2.18 (Y-), U4.5 (YN)
/YP: U2.16 (Y+), U4.3 (YP)
GND: C1.2, C2.2, C3.2, C5.2, C7.2, C8.1, C9.1, C10.1, C11.2, C12.2, C13.1, C14.2, C15.2, C16.2, C17.2, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, D1.2 (A), D2.2 (A), D9.2 (A), J7.2 (GND), J7.MP, J8.2, J8.3, M1.5 (GND), M2.5 (GND), Q1.1 (E), Q2.1, Q3.1, Q4.1, Q5.1, R5.1, R8.1, R9.1, R11.1, R13.2, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, R25.1, R26.1, R27.1, U1.6 (GND), U1.9 (GND), U1.14 (GND), U1.20 (GND), U1.25 (GND), U1.30 (GND), U1.34 (GND), U1.39 (GND), U2.1 (GND), U2.8 (GND), U3.1 (CLKIN), U3.11 (FSYNC), U3.18 (GND), U4.6 (GND), U4.7 (VBAT), U4.8 (IN), U5.1 (1OE), U5.10 (GND), U5.19 (2OE), U6.5 (GND), U7.7 (VSS), U7.15 (VSS), U8.2 (GND)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
unnamed: C4.1, R8.2
unnamed: C4.2, U6.3 (COMP)
unnamed: C6.1, D9.1 (K), L1.2, U6.1 (SW)
unnamed: C6.2, U6.8 (BST)
unnamed: C12.1, U3.10 (REGOUT)
unnamed: C17.1, U3.20 (CPOUT)
unnamed: C19.2, U7.5 (OSC2), Y1.3
unnamed: C20.2, U7.6 (OSC1), Y1.1
unnamed: C24.2, D1.1 (A), J1.1, R6.2, U8.7 (CANH)
unnamed: C25.2, D2.1 (A), J1.2, R28.2, U8.6 (CANL)
unnamed: C26.2, R6.1, R28.1
unnamed: Q1.2 (B), R1.2
unnamed: Q1.3 (C), U2.11 (LEDK1), U2.12 (LEDK2), U2.13 (LEDK3), U2.14 (LEDK4)
unnamed: Q2.2 (IN), U5.18 (1Y0)
unnamed: Q2.3 (INH), U5.16 (1Y1)
unnamed: Q2.5 (SR), R22.2
unnamed: Q2.6 (IS), R20.2
unnamed: Q3.2 (IN), U5.14 (1Y2)
unnamed: Q3.3 (INH), U5.12 (1Y3)
unnamed: Q3.5 (SR), R21.2
unnamed: Q3.6 (IS), R23.2
unnamed: Q4.2 (IN), U5.3 (2Y0)
unnamed: Q4.3 (INH), U5.5 (2Y1)
unnamed: Q4.5 (SR), R26.2
unnamed: Q4.6 (IS), R24.2
unnamed: Q5.2 (IN), U5.7 (2Y2)
unnamed: Q5.3 (INH), U5.9 (2Y3)
unnamed: Q5.5 (SR), R25.2
unnamed: Q5.6 (IS), R27.2
unnamed: R5.2, U3.9 (AD0)
unnamed: R9.2, R10.2, U6.4 (FB)
unnamed: R11.2, U6.6 (FREQ)
unnamed: R12.2, R13.1, U6.2 (EN)
unnamed: U7.1 (TXCAN), U8.1 (TXD)
unnamed: U7.2 (RXCAN), U8.4 (RXD)

Board: 2 copper layers, 56.0 x 86.0 mm, 77 parts (1 on the bottom side), 73 nets.

## KiCad design docs/kicad/rk3566/rk3566.kicad_pcb

Parts:
C1, C22: 10uf; C_0603_1608Metric
C2, C4, C6, C9, C11, C12, C13, C17, C18, C20, C30, C31: 104; C_0402_1005Metric
C3, C5, C7, C8, C10, C14, C15, C16, C19: 10uf; C_0805_2012Metric
C21: 2200pf; C_0402_1005Metric
C23: C_Polarized_Small_US; CP_Radial_D5.0mm_P2.50mm
C24, C28: 10uF; C_0603_1608Metric
C25: 100pF; C_0402_1005Metric
C26, C27, C29: 100nF; C_0402_1005Metric
D1: D; D_MELF
J1, J6: 超声波接口; HDR1x04_2.54mm
J2: Barrel_Jack_Switch_Pin3Ring; BarrelJack_GCT_DCJ200-10-A_Horizontal
J3: sbus; SBUS
J4: 舵机接口; SBUS
J5: GPS; EAI_S4
J7: EAI_S4
J8: 2.4TFT_SPI; 2.4_TFT_SPI
J9: VL53L0; HDR1x06_2.54mm
L1: 4.7uH; L_6.3x6.3_H3
M1: 带码盘电机; HDR1x06_2.54mm
Q1: S8050; s8050
Q2, Q3: BTN8982TA; TO-263-7_TabPin8
R1, R5, R6, R7: 4.7K; R_0402_1005Metric
R2, R3, R4: 10K; R_0402_1005Metric
R9, R10, R11, R13, R14, R15, R16: 1K; R_0402_1005Metric
R17, R20, R21, R22: 100K; R_0402_1005Metric
R18: 40.2K; R_0402_1005Metric
R19: 210K; R_0402_1005Metric
SW1: SW_SPDT; TerminalBlock_RND_205-00288_1x03_P5.08mm_Horizontal
U1: 树莓派接口; HEARD2x40
U2: MPU-6050; InvenSense_QFN-24_4x4mm_P0.5mm
U3: 74AHC244
U4: MP1584EN; HTSOP-8-1EP_3.9x4.9mm_Pitch1.27mm_LargeCopper

Connections:
+3.3V: C3.1, C4.1, C10.1, C12.1, C13.2, C15.1, C17.1, C19.1, C20.1, C22.2, J8.1 (VCC), J9.1 (VCC), M1.4 (VCC), R3.2, R4.2, R5.1, R6.1, U1.1 (3.3V), U1.17 (3.3V), U2.8 (VDDIO), U2.13 (VDD), U3.20 (VCC); also elsewhere on the board
+5V: C1.1, C2.1, C5.1, C6.1, C7.1, C8.1, C9.1, C11.1, C14.2, C16.1, C18.1, C24.1, C26.1, C31.2, J1.4 (VCC), J3.2 (5V), J4.2 (5V), J5.4 (VCC), J6.4 (VCC), J7.4 (5V), L1.1, R19.1, U1.2 (5V), U1.4 (5V)
+12V: C23.1, C28.1, C29.2, Q2.7, Q3.7, R21.1, SW1.2 (B), U4.7 (VIN)
+BATT: J2.1, SW1.3 (C)
/DC: J8.5 (DC), U1.38 (GPIO.28)
/ECHO1: J1.2 (ECHO), U1.29 (GPIO.21)
/ECHO2: J6.2 (ECHO), U1.22 (GPIO.6)
/INTA: M1.5 (A), U1.11 (GPIO.0)
/INTB: M1.6 (B), U1.7 (GPIO.7)
/LCD_CS: J8.3 (CS), U1.24 (CE0)
/LPWM: R11.2, U1.18 (GPIO.5), U3.6 (1A2)
/L_IS: Q3.6 (IS), R14.2
/M+: M1.1 (MOTOR+), Q2.4, Q2.8
/M-: M1.2 (MOTOR-), Q3.4, Q3.8
/MISO: J8.9 (MISO), J8.13 (T_MISO), U1.21 (MISO)
/MOSI: J8.6 (MOSI), J8.12 (T_MOSI), U1.19 (MOSI)
/MPU_INT: U1.13 (GPIO.2), U2.12 (INT)
/PWM3: J7.1 (PWM), U1.12 (GPIO.1)
/PWM8: J8.8 (LED), U1.33 (GPIO.23)
/PWM9: R10.2, U1.35 (GPIO.24), U3.4 (1A1), U3.8 (1A3)
/PWM11: J4.3 (PWM), U1.32 (GPIO.26)
/RESET: J8.4 (RESET), R4.1, U1.37 (GPIO.25)
/RPWM: R9.2, U1.15 (GPIO.3), U3.2 (1A0)
/RXD3: Q1.3 (C), R3.1, U1.3 (SDA.1)
/RXD8: J5.2 (TXD), J7.3 (TX), U1.10 (RXD)
/R_IS: Q2.6 (IS), R13.2
/SCL5: J9.3 (SCL), R6.2, U1.28 (SCL.0), U2.23 (SCL)
/SCLK: J8.7 (SCK), J8.10 (T_CK), U1.23 (SCLK)
/SDA5: J9.4 (SDA), R5.2, U1.27 (SDA.0), U2.24 (SDA)
/TRIG1: J1.3 (TRIG), U1.31 (GPIO.22)
/TRIG2: J6.3 (TRIG), U1.16 (GPIO.4)
/TXD8: J5.1 (RXD), U1.8 (TXD)
/T_CS: J8.11 (T_CS), U1.26 (CE1)
/T_INT: J8.14 (T_IRQ), U1.40 (GPIO.29)
/V_INT: J9.5 (GPIO1), U1.36 (GPIO.27)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.1, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.1, C23.2, C24.2, C26.2, C28.2, C29.1, C30.2, C31.1, D1.2 (A), J1.1 (GND), J2.2, J2.3, J3.1 (GND), J4.1 (GND), J5.3 (GND), J5.MP, J6.1 (GND), J7.2 (GND), J7.MP, J8.2 (GND), J9.2 (GND), M1.3 (GND), Q1.1 (E), Q2.1, Q3.1, R2.2, R7.1, R9.1, R10.1, R11.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R20.1, R22.2, U1.6 (GND), U1.9 (GND), U1.14 (GND), U1.20 (GND), U1.25 (GND), U1.30 (GND), U1.34 (GND), U1.39 (GND), U2.1 (CLKIN), U2.11 (FSYNC), U2.18 (GND), U3.1 (1OE), U3.10 (GND), U3.11 (2A3), U3.13 (2A2), U3.15 (2A1), U3.17 (2A0), U3.19 (2OE), U4.5 (GND); also elsewhere on the board
unnamed: C21.1, U2.20 (CPOUT)
unnamed: C25.1, R17.2
unnamed: C25.2, U4.3 (COMP)
unnamed: C27.1, D1.1 (K), L1.2, U4.1 (SW)
unnamed: C27.2, U4.8 (BST)
unnamed: C30.1, U2.10 (REGOUT)
unnamed: J3.3 (RXD), R1.1
unnamed: Q1.2 (B), R1.2, R2.1
unnamed: Q2.2 (IN), U3.18 (1Y0)
unnamed: Q2.3 (INH), U3.16 (1Y1)
unnamed: Q2.5 (SR), R15.2
unnamed: Q3.2 (IN), U3.14 (1Y2)
unnamed: Q3.3 (INH), U3.12 (1Y3)
unnamed: Q3.5 (SR), R16.2
unnamed: R7.2, U2.9 (AD0)
unnamed: R18.2, R19.2, U4.4 (FB)
unnamed: R20.2, U4.6 (FREQ)
unnamed: R21.2, R22.1, U4.2 (EN)

Notes on the sheet:
2023/02/08
树莓派小车控制板

Board: 2 copper layers, 58.4 x 78.0 mm, 73 parts (14 on the bottom side), 54 nets.

Other parts of the board:
C13#2: 10uf; C_0805_2012Metric
C14#2: 104; C_0402_1005Metric

Their connections:
+3.3V: C13#2.1, C14#2.1; also elsewhere on the board
GND: C13#2.2, C14#2.2; also elsewhere on the board

## Code that names these connections

File docs/rk3566-lubancat-0.dts (part):

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		moto-enb {
			label = "moto-enb";
			pinctrl-names = "default";
			pinctrl-0 = <&lpwm_pin>;
			gpios = <&gpio2 RK_PC4 GPIO_ACTIVE_HIGH>; // GPIO2_C4
			default-state = "on";
		};
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		moto-ena {
			label = "moto-ena";
			pinctrl-names = "default";
			pinctrl-0 = <&rpwm_pin>;
			gpios = <&gpio1 RK_PA5 GPIO_ACTIVE_HIGH>; // GPIO1_A5
			default-state = "on";
		};
	};
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		compatible = "devantech,srf04";
		pinctrl-names = "default";
		pinctrl-0 = <&srf04_pin_1>;
		trig-gpios = <&gpio1 RK_PB0 GPIO_ACTIVE_HIGH>; // GPIO1_B0
		echo-gpios = <&gpio1 RK_PA7 GPIO_ACTIVE_HIGH>; // GPIO1_A7
        status = "okay";
	};

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		compatible = "rotary-encoder";
		pinctrl-names = "default";
		pinctrl-0 = <&rotary_pin>;
		gpios = <&gpio1 RK_PA2 GPIO_ACTIVE_HIGH>, <&gpio1 RK_PA3 GPIO_ACTIVE_HIGH>; //GPIO1_PA2 GPIO1_PA3
		linux,axis = <0>; /* REL_X */
		rotary-encoder,encoding = "gray";
		rotary-encoder,relative-axis;
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	};

	lpwm {
		lpwm_pin: lpwm-pin {
			rockchip,pins = <2 RK_PC4 RK_FUNC_GPIO &pcfg_pull_none>;
		};
	};

	rpwm {
		rpwm_pin: rpwm-pin {
			rockchip,pins = <1 RK_PA5 RK_FUNC_GPIO &pcfg_pull_none>;
		};
	};
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	pinctrl-names = "default";
	pinctrl-0 = <&spi3m1_pins &spi3_pins_cs>;
	spi-num-chipselects = <3>;
	cs-gpios = <&gpio4 RK_PC6 GPIO_ACTIVE_HIGH>, <&gpio1 RK_PB3 GPIO_ACTIVE_HIGH>, <&gpio2 RK_PC3 GPIO_ACTIVE_HIGH>;
	status = "okay";

	ili9341@0 {
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		status = "okay";
		compatible = "ti,tsc2046";
		pinctrl-names = "default";
		pinctrl-0 = <&t_irq>;
		interrupt-parent = <&gpio3>;
		interrupts = <RK_PA7 IRQ_TYPE_LEVEL_LOW>; // GPIO3_A7
		spi-max-frequency = <1000000>;
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        spi-max-frequency = <8000000>;
		pinctrl-names = "default";
		pinctrl-0 = <&rfid_int>;
		interrupt-parent = <&gpio1>;
		interrupts = <RK_PB1 IRQ_TYPE_LEVEL_LOW>; // GPIO1_B1
    };
};
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		compatible = "invensense,mpu6050";
		reg = <0x68>;
		status = "disabled";
		interrupt-parent = <&gpio1>;
		interrupts = <RK_PA4 IRQ_TYPE_EDGE_RISING>; // GPIO1_A4
		orientation = <0xff 0 0 0 1 0 0 0 0xff>;
	};
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
## Commit log

2024-03-04 更新原理图
2024-03-04 更新链接
2024-03-17 更新打印
2024-03-17 更新配置文件
2024-03-17 更新配置
2024-05-23 thin
2024-05-23 jianhua
2024-05-23 更新版本判断
2024-06-17 更新启动文件
2024-06-17 适配成功
2024-06-17 更新信息
2024-06-18 更新机型
2024-06-19 修复接口
2024-06-19 添加底盘说明
2024-06-21 修正文档错误
2024-06-21 更新文件名
2024-06-26 更新雷达转速
2024-07-09 添加乐动雷达
2024-07-10 更新距离传感器
2024-07-10 更新tof
2024-07-14 添加脚本
2024-07-14 更新名称
2024-07-19 修复编码器
2024-07-19 添加泰山派启动
2024-07-21 默认泰山派
2024-08-15 添加遥控
2024-08-16 添加udp控制支持
2024-08-17 更新失控标识
2024-08-18 更新遥控参数
2024-08-19 更新IMU
2024-08-28 修复警告
2025-02-16 更新脚本
2025-02-16 更新包编译说明
2025-02-16 更新PWM
2025-07-06 修复遥控
2026-04-26 更新遥控
2026-04-27 更新变量范围
2026-04-29 更新支持
2026-04-30 更新版本
2026-05-05 更新泰山派配置
2026-05-05 更新sbuc遥控
2026-05-05 修复变量
2026-05-05 修改背光

Notices in the files:
docs/rk3566-lubancat-0.dts:
SPDX-License-Identifier: (GPL-2.0+ OR MIT)
Copyright (c) 2020 Rockchip Electronics Co., Ltd.
